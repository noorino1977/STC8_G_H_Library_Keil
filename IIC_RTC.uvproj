# Keil uVision project IIC_RTC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: IIC_RTC +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_SPI.c
